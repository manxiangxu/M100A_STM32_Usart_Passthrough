# Keil uVision project m100a_usart_passthrough.uvproj, settings and files
target M100A_LORAWAN_USART_PASSTHROUGH (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: m100a_lorawan_usart_passthrough +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_BAND_433 STM32L1XX_MD USE_STDPERIPH_DRIVER USE_MODEM_LORA USE_DEBUGGER USE_LORAWAN_PASSTHROUGH
  c misc: --c99
  c include: ..\User\apps\LoRaMac\classA\M100A;..\User\boards\M100A;..\User\boards\M100A\cmsis;..\User\boards\mcu\stm32;..\User\boards\mcu\stm32\cmsis;..\User\boards\mcu\stm32\STM32L1xx_StdPeriph_Driver\inc;..\User\mac;..\User\radio;..\User\system;..\User\system\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group apps
    ../User/apps/LoRaMac/classA/M100A/: main.c
  group boards\M100A
    ../User/boards/M100A/: board.c gpio-board.c m100a-board.c rtc-board.c spi-board.c sx1276-board.c timer-board.c uart-board.c crc16.c lorawan_passthrough.c non-lorawan_passthrough.c stm32_eeprom_lib.c
  group boards\M100A\cmsis
    ../User/boards/M100A/cmsis/: system_stm32l1xx.c
    ../User/boards/M100A/cmsis/arm-std/: startup_stm32l1xx_md.s
  group boards\M100A\STM32L1xx_StdPeriph_Driver
    ../User/boards/mcu/stm32/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_pwr.c stm32l1xx_dbgmcu.c stm32l1xx_syscfg.c
  group boards\mcu\stm32
    ../User/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group mac
    ../User/mac/: LoRaMac.c LoRaMacCrypto.c
  group radio
    ../User/radio/sx1276/: sx1276.c
  group system
    ../User/system/: delay.c fifo.c gpio.c timer.c uart.c
  group system\crypto
    ../User/system/crypto/: aes.c cmac.c
target M100A_NON_LORAWAN_USART_PASSTHROUGH (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  cpu: as above
  output: m100a_non_lorawan_usart_passthrough +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: LOW_POWER_MODE_ENABLE USE_BAND_433 STM32L1XX_MD USE_STDPERIPH_DRIVER USE_MODEM_LORA USE_DEBUGGER
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
